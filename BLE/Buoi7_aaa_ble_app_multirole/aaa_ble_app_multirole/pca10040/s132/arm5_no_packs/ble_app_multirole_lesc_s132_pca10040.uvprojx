# Keil uVision project ble_app_multirole_lesc_s132_pca10040.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: USE_APP_CONFIG APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD MBEDTLS_CONFIG_FILE=<nrf_crypto_mbedtls_config.h> NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_CRYPTO_MAX_INSTANCE_COUNT=1 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\..\components\ble\nrf_ble_gq;..\..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\..\components\ble\nrf_ble_scan;..\..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310;..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\..\..\..\..\components\libraries\crypto\backend\cifra;..\..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\..\..\..\..\components\libraries\crypto\backend\oberon;..\..\..\..\..\..\..\components\libraries\crypto\backend\optiga;..\..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\..\components\libraries\stack_info;..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\external\mbedtls\include;..\..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\..\external\nrf_oberon;..\..\..\..\..\..\..\external\nrf_oberon\include;..\..\..\..\..\..\..\external\nrf_tls\mbedtls\nrf_crypto\config;..\..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\..\modules\nrfx\hal;..\config;..\..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\aaa_ble_app_multirole;..\..\..\..\..\..\..\..\..\..\nRF5SDK1702d674dde\nRF5_SDK_17.0.2_d674dde\components\ble\ble_link_ctx_manager
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_CRYPTO_MAX_INSTANCE_COUNT=1 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_CRYPTO_MAX_INSTANCE_COUNT=1,-DNRF_SD_BLE_API_VERSION=7,-DS132,-DSOFTDEVICE_PRESENT,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-D__HEAP_SIZE=0
  asm include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\..\components\ble\nrf_ble_gq;..\..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\..\components\ble\nrf_ble_scan;..\..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310;..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\..\..\..\..\components\libraries\crypto\backend\cifra;..\..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\..\..\..\..\components\libraries\crypto\backend\oberon;..\..\..\..\..\..\..\components\libraries\crypto\backend\optiga;..\..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\..\components\libraries\stack_info;..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\external\mbedtls\include;..\..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\..\external\nrf_oberon;..\..\..\..\..\..\..\external\nrf_oberon\include;..\..\..\..\..\..\..\external\nrf_tls\mbedtls\nrf_crypto\config;..\..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\..\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x200039d8 size 0xc628
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c app_config.h
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group nRF_BLE
    ../../../../../../../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c nrf_ble_lesc.c security_dispatcher.c security_manager.c
    ../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../../../../../components/ble/nrf_ble_gq/: nrf_ble_gq.c
    ../../../../../../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../../../../../../../components/ble/nrf_ble_scan/: nrf_ble_scan.c
    ../../../../../../../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
  group nRF_BLE_Services
    ../../../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
    ../../../../../../../components/ble/ble_services/ble_nus_c/: ble_nus_c.c
  group nRF_Drivers
    ../../../../../../../integration/nrfx/legacy/: nrf_drv_rng.c nrf_drv_uart.c
    ../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../modules/nrfx/drivers/src/: nrfx_gpiote.c nrfx_rng.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../../components/libraries/fds/: fds.c
    ../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_TLS
    ../../../../../../../external/mbedtls/library/: aes.c ctr_drbg.c platform_util.c
  group nrf_cc310
    ../../../../../../../external/nrf_cc310/lib/cortex-m4/hard-float/short-wchar/: nrf_cc310_0.9.13.lib
target flash_s132_nrf52_7.2.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: s132_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=0
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=0
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=0
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x200028c8 size 0xd738
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
